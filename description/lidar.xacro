Commit message: done with camera

File: description/lidar.xacro (robot description, xacro)
@@ -25,4 +25,5 @@
     </link>
     <gazebo reference="laser_frame">
+        <material>Gazebo/Black</material>
         <sensor type="ray" name="laser">
             <pose>0 0 0 0 0 0</pose>
